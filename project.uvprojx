# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn947 (6220000::V6.22::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.17.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __perf_counter_printf__=rt_kprintf, CPU_MCXN947VDF_cm33_core0, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, DEBUG, ARDUINO_ARCH_RTTHREAD=10000, __STDC_LIMIT_MACROS, ARDUINO=10819, __RTTHREAD__
  c misc: --target=arm-arm-none-eabi
  c include: rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\sal\include\socket\sys_socket;packages\RTduino-latest\core;packages\i2c-tools-latest;rt-thread\components\net\sal\include;rt-thread\components\libc\posix\io\epoll;Libraries\drivers;rt-thread\components\utilities\ulog;rt-thread\components\libc\posix\ipc;board;rt-thread\components\drivers\include;packages\uMCN-latest\inc;rt-thread\components\libc\cplusplus;rt-thread\libcpu\arm\cortex-m33;rt-thread\components\drivers\spi;Libraries\MCXN947\MCXN947\drivers;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;Libraries\drivers\config;.;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\netdev\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\finsh;rt-thread\libcpu\arm\common;rt-thread\components\net\sal\impl;packages\RTduino-latest\libraries\buildin\Wire;packages\RTduino-latest\libraries\user;rt-thread\components\drivers\include;packages\i2c-tools-latest\src;rt-thread\components\net\lwip\port;Libraries\CMSIS\Core\Include;Libraries\MCXN947\MCXN947;rt-thread\components\net\sal\include\socket;applications;packages\perf_counter-v2.2.4.1;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;packages\uMCN-latest\examples;rt-thread\components\libc\posix\io\eventfd;rt-thread\include;board\MCUX_Config\board
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  group Applications
    applications/: tcp_event_handle.c st7735_demo.c touch_check.c tcp_client_demo.c main.c sensor_demo.cpp temp_read.cpp
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/sensor/v2/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: Adafruit_APDS9960.cpp Adafruit_I2CDevice.cpp board.c st7735s.c st7735s_conf.c
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    Libraries/drivers/: drv_eth.c drv_pin.c drv_spi.c drv_uart.c
  group Finsh
    rt-thread/components/finsh/: msh.c cmd.c msh_parse.c shell.c
  group i2c-tools
    packages/i2c-tools-latest/src/: i2c_tools.cpp SoftwareI2C.cpp i2c_utils.cpp
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    Libraries/MCXN947/MCXN947/drivers/: fsl_flexio_uart_edma.c fsl_vref.c fsl_lpi2c_edma.c fsl_reset.c fsl_flexspi.c fsl_flexcan.c fsl_cdog.c fsl_erm.c fsl_crc.c fsl_i3c.c fsl_cache_lpcac.c fsl_lpspi.c fsl_evtg.c fsl_usdhc.c fsl_dac14.c fsl_spc.c fsl_irtc.c fsl_enc.c fsl_flexio_spi.c fsl_tsi_v6.c fsl_itrc.c fsl_lpuart.c fsl_edma.c fsl_lpspi_edma.c fsl_common.c fsl_flexio.c fsl_inputmux.c fsl_edma_soc.c fsl_mrt.c fsl_flexio_mculcd.c fsl_dac.c fsl_enet.c fsl_common_arm.c fsl_clock.c fsl_flexio_i2c_master.c fsl_lptmr.c fsl_lpadc.c fsl_gpio.c fsl_eim.c fsl_lpi2c.c fsl_flexio_uart.c fsl_flexspi_edma.c fsl_lpflexcomm.c fsl_flexio_mculcd_edma.c fsl_cmc.c fsl_flexio_spi_edma.c fsl_ctimer.c fsl_cache.c fsl_ewm.c
    Libraries/MCXN947/MCXN947/: system_MCXN947_cm33_core0.c
    Libraries/MCXN947/MCXN947/arm/: startup_MCXN947_cm33_core0.s
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group perf_counter
    packages/perf_counter-v2.2.4.1/: perf_counter.c
    packages/perf_counter-v2.2.4.1/os/: perf_os_patch_rt_thread.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group RTduino-core
    packages/RTduino-latest/core/avr/: avr_stdlib.c
    packages/RTduino-latest/core/: Stream.cpp IPAddress.cpp wiring.c HardwareSerial.cpp Print.cpp WMath_c.c WString.cpp WMath_cpp.cpp RTduino.cpp
  group RTduino-libraries-buildin
    packages/RTduino-latest/libraries/buildin/Wire/: Wire.cpp
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group uMCN
    packages/uMCN-latest/examples/: example_umcn.c
    packages/uMCN-latest/src/: uMCN.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
